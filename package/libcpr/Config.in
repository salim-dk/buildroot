## package/libcpr/Config.in
```kconfig
config BR2_PACKAGE_LIBCPR
    bool "libcpr"
    help
        C++ Wrapper for Curl

        https://github.com/whoshuu/cpr
```
